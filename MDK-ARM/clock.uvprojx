# Keil uVision project clock.uvprojx, settings and files
target clock (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: clock +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --no-multibyte-chars
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\Drivers\Peripherals\Key;..\Drivers\Peripherals\Led;..\Drivers\Peripherals\Uart;..\Drivers\Peripherals\Spi;..\Drivers\Peripherals\Spi\W25q64_hal;..\Drivers\Peripherals\Spi\W25q64;..\Drivers\Peripherals\Spi\St7789_hal;..\Drivers\Peripherals\Spi\St7789;..\App\Inc;..\Drivers\Peripherals\Esp32
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Application/Threads
    ../App/Src/: thread_network_rx.c thread_application.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_spi.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Drivers/Peripherals
    ../Drivers/Peripherals/Key/: key.c
    ../Drivers/Peripherals/Led/: led.c
    ../Drivers/Peripherals/Uart/: uart.c
    ../Drivers/Peripherals/Spi/: spi_device.c
    ../Drivers/Peripherals/Spi/W25q64_hal/: w25q64_hal.c
    ../Drivers/Peripherals/Spi/W25q64/: w25q64.c
    ../Drivers/Peripherals/Spi/St7789/: st7789.c
    ../Drivers/Peripherals/Spi/St7789_hal/: st7789_hal.c
    ../Drivers/Peripherals/Esp32/: esp32_hardware.c esp32.c at.c
  group App
    ../App/Src/: common.c update_font_lib.c ymodem.c font.c lcd.c clk.c astronaut.c weather.c update.c num.c xmodem_app.c state.c
software components: CMSIS:CORE 5.4.0
